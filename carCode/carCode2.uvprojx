# Keil uVision project carCode2.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: carCode2
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\include;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./: main.c
    ./source/: test.c carTasks.c peripheralFunctions.c irqHandler.c interrupt_stmConf.c GPIO_RCC_stmConf.c timers_stmConf.c
  group FreeRTOS
    ./FreeRTOS-Source/: list.c queue.c tasks.c timers.c
    ./FreeRTOS-Source/portable/MemMang/: heap_1.c
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
  group Startup
    ./: startup_MPS_CM3.s
software components: CMSIS:CORE 4.3.0
